# Keil uVision project PWM_Capture.uvprojx, settings and files
target PWM_Capture (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC123SD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.2
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: PWM_Capture
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC123\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --map --first='startup_NUC123.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC123/Source/: system_NUC123.c
    ../../../../Library/Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group User
    ../: main.c
  group Library
    C:/Users/dnguy/OneDrive/Documents/GitHub/LogiCar/NUC123BSP-master/Library/StdDriver/src/: retarget.c
    C:/Users/dnguy/OneDrive/Documents/GitHub/LogiCar/NUC123BSP-master/Library/StdDriver/src//: clk.c pwm.c uart.c sys.c
software components: CMSIS:CORE 5.1.2
